# Keil uVision project SNR_StdPeriph.uvprojx, settings and files
target SNR 85x Project (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SNR_MC_Project +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c include: .\Include;.\SNR8503x_Periph_Driver\include;.\SEGGER_RTT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group AppFunction
    ./AppFunction/: hardware_init.c Global_Variable.c System_Init.c
    ./Kernal_Source/: MosTest.c
  group Kernal
    ./Kernal_Source/: main.c Protect.c interrupt.c M1_StateMachine.c Sensor_Control.c
  group Motor_Run
    ./Kernal_Source/: SpeedRamp.c MC_Drive.c PID.c UR_Ctrl.c
  group User_Parameter
    ./Include/: MC_Parameter.h
  group Periph_Driver
    ./SNR8503x_Periph_Driver/Source/: delay.c snr8503x_adc.c snr8503x_cmp.c snr8503x_DMA.c snr8503x_dsp.c snr8503x_Flash.c snr8503x_gpio.c snr8503x_hall.c snr8503x_I2C.c snr8503x_IWDG.c snr8503x_MCPWM.c snr8503x_spi.c snr8503x_sys.c snr8503x_timer.c snr8503x_uart.c snr8503x_dac.c snr8503x_nvr.lib
    ./SNR8503x_Periph_Driver/include/: startup_snr8503x.s
  group SEGGER_RTT
    ./SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Motor_Lib
    ./Kernal_Source/: SNR_BLDC_HALL_V1p0.lib
